#define N 8   
char A[N][N] = {  
	{1,1,1,1,1,1,1,1}, 
	{2,2,2,2,2,2,2,2}, 
	{3,3,3,3,3,3,3,3},  
	{4,4,4,4,4,4,4,4},  
	{5,5,5,5,5,5,5,5},  
	{6,6,6,6,6,6,6,6},  
	{7,7,7,7,7,7,7,7},  
	{8,8,8,8,8,8,8,8}
};  

char B[N][N] = {  
	{1,2,3,4,5,6,7,8},  
	{1,2,3,4,5,6,7,8},  
	{1,2,3,4,5,6,7,8}, 
	{1,2,3,4,5,6,7,8},  
	{1,2,3,4,5,6,7,8},  
	{1,2,3,4,5,6,7,8},  
	{1,2,3,4,5,6,7,8},  
	{1,2,3,4,5,6,7,8}   
};  

char C[N][N] = { 
	{0,0,0,0,0,0,0,0}, 
	{0,0,0,0,0,0,0,0},  
	{0,0,0,0,0,0,0,0}, 
	{0,0,0,0,0,0,0,0}, 
	{0,0,0,0,0,0,0,0}, 
	{0,0,0,0,0,0,0,0}, 
	{0,0,0,0,0,0,0,0}, 
	{0,0,0,0,0,0,0,0} 
};  



void main() { 

	int i, j, k, tmp; 

	for (i=0; i < N; i++) { 
		for (j= 0; j<N ; j++){  
			tmp = 0;  
			for (k = 0 ; k < N ; k++) { 
				tmp += A[i][k] * B[k][j]; 
			} 
			C[i][j] = tmp; 
		}  
	}  

} 